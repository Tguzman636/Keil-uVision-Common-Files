# Keil uVision project Lab1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Lab1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\FinalProject\compat;.\FinalProject\Config;.\FinalProject\Core\Inc;.\FinalProject\Core\Src;.\FinalProject\Drivers\STM32L4xx_HAL_Driver\Inc;.\FinalProject\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;.\FinalProject\Drivers\STM32L4xx_HAL_Driver\Src;.\FinalProject\Drivers\CMSIS;.\FinalProject\Drivers\BSP\STM32L476G-Discovery;.\FinalProject\EWARM;.\FinalProject\third;.\FinalProject\Drivers\BSP\Components\Common;.\FinalProject\Drivers\BSP\Components\cs43l22;.\FinalProject\Drivers\BSP\Components\hx8347g;.\FinalProject\Drivers\BSP\Components\l3gd20;.\FinalProject\Drivers\BSP\Components\lsm303c;.\FinalProject\Drivers\BSP\Components\mfxstm32l152;.\FinalProject\Drivers\BSP\Components\n25q128a;.\FinalProject\Drivers\BSP\Components\n25q256a;.\FinalProject\Drivers\BSP\Components\st7735;.\FinalProject\Drivers\BSP\Components\stmpe811;.\FinalProject\Drivers\BSP\Components\stmpe1600;.\FinalProject\Drivers\BSP\Components\wm8994
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group New Group
    ./FinalProject/: GPIO.c GPIO.h main.c SSPI.c SSPI.h LCD_Draw.c startup_stm32l476xx.s stm32l476xx.h SysClock.c SysClock.h SysTimer.c SysTimer.h UTIL.c UTIL.h LCD_Draw.h game.c I2C.c I2C.h game.h
software components: CMSIS:CORE 5.5.0
